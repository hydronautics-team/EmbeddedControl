# Keil uVision project EmbeddedControl-Refactored.uvprojx, settings and files
target EmbeddedControl-Refactored (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F303VCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EmbeddedControl-Refactored
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xC
  c misc: --C99
  c include: ../Inc;                 ../Drivers/STM32F3xx_HAL_Driver/Inc;                 ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;                 ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;                 ../Drivers/CMSIS/Device/ST/STM32F3xx/Include;                 ../Middlewares/Third_Party/FreeRTOS/Source/include;                 ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                 ../Drivers/CMSIS/Include
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f303xc.s
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: timers.c queue.c list.c event_groups.c tasks.c croutine.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Application/User
    ../Src/: u_checksum.c u_communication.c u_FreeRTOSTick.c u_PID.c u_stabilization.c u_global.c dma.c stm32f3xx_hal_msp.c i2c.c usart.c iwdg.c tim.c main.c freertos.c stm32f3xx_hal_timebase_TIM.c stm32f3xx_it.c gpio.c
    ../Inc/: u_messages.h
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_tim.c stm32f3xx_hal.c stm32f3xx_hal_gpio.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_uart.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_iwdg.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
software components: CMSIS:CORE 4.1.0
